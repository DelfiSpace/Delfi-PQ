options:
  parameters:
    author: stefanosperett
    generate_options: qt_gui
    id: DemodulateDelfiPQ
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/stefanosperett/Documents/PocketQube/GroundSoftware/DelfiPQ_1200bps_short.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Delfi-PQ - 1200 bps"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
    options: '"--deviation=600"'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '1200'
    iq: 'True'
    options: '"--deviation=600"'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: satellites_telemetry_parser_0
  id: satellites_telemetry_parser
  parameters:
    definition: delfipq
    output: stdout
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', satellites_fsk_demodulator_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [satellites_ax25_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_ax25_deframer_0, out, satellites_telemetry_parser_0, in]
- [satellites_fsk_demodulator_0, '0', satellites_ax25_deframer_0, '0']

metadata:
  file_format: 1
